# Keil uVision project TFT9K2353A0-A.uvproj, settings and files
target STM3210B-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TFT9K5253_0510A +hex
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\project;..\..\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../: stm32f10x_it.c main.c LCD.c
  group FWLib
    ../: SDFAT.lib DispBMPv01.lib TSLIIC_REV01.lib
    ../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RVMDK
    ./: stm32f10x_vector.s cortexm3_macro.s
  group Doc
    ./: readme.txt
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: as above
  output: GPM043LL_V054_ALL +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: VECT_TAB_FLASH
  c include: ..\..\project;..\..\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
